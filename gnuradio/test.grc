options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: channel_spacing
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: channel_trans
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '2950'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 318e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/data_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/data_rate)
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.4'
    init: '0'
    low: '0.1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: |-
      firdes.low_pass(1, samp_rate,
      channel_spacing, channel_trans, firdes.WIN_BLACKMAN, 6.76)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: '20'
    freq0: freq+freq_offset
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: freq
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_scopesink2_0
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    num_inputs: '1'
    samp_rate: data_rate
    t_scale: '0.01'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_FREE
    type: float
    v_offset: '.4'
    v_scale: '1'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {}
- name: wxgui_scopesink2_1
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    num_inputs: '1'
    samp_rate: samp_rate
    t_scale: '0.01'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_FREE
    type: float
    v_offset: '0'
    v_scale: '0'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_1, '0', wxgui_scopesink2_1, '0']
- [blocks_keep_one_in_n_0, '0', wxgui_scopesink2_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', wxgui_fftsink2_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
